options:
  parameters:
    author: Perspecta Labs, Inc.
    generate_options: qt_gui
    id: ctf_solution_zmq
    output_language: python
    title: Capture The Flag
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '4'
  states: {}
- name: angle1
  id: variable
  parameters:
    value: '40'
  states: {}
- name: angle2
  id: variable
  parameters:
    value: '80'
  states: {}
- name: angle3
  id: variable
  parameters:
    value: '15'
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    const_points: '[1,-1]'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0,1]'
    type: qpsk
  states: {}
- name: corr_calc
  id: variable
  parameters:
    value: corr_thresh/(corr_max*corr_max)
  states: {}
- name: corr_calc_2
  id: variable
  parameters:
    value: corr_thresh_2/(corr_max_2*corr_max_2)
  states: {}
- name: corr_max
  id: variable
  parameters:
    value: numpy.abs(numpy.dot(modulated_sync_word,numpy.conj(modulated_sync_word)))
  states: {}
- name: corr_max_2
  id: variable
  parameters:
    value: numpy.abs(numpy.dot(modulated_sync_word,numpy.conj(modulated_sync_word)))
  states: {}
- name: corr_thresh
  id: variable_qtgui_range
  parameters:
    label: Correlation Threshold 1
    orient: Qt.Horizontal
    start: '0.1'
    step: '1.0'
    stop: 1e6
    value: 800e3
  states: {}
- name: corr_thresh_2
  id: variable_qtgui_range
  parameters:
    label: Correlation Threshold 2
    orient: Qt.Horizontal
    start: '1.0'
    step: '1'
    stop: 1e6
    value: 800e3
  states: {}
- name: eb
  id: variable
  parameters:
    value: '.35'
  states: {}
- name: gold_preambles
  id: variable
  parameters:
    value: '[[0x27,0x2F,0x18,0x5D,0x5B,0x2A,0x3F,0x71,0x63,0x3C,0x17,0x0C,0x0A,0x41,0xD6,0x1F,0x4C,0x23,0x65,0x68,0xED,0x1C,0x77,0xA7,0x0E,0x0A,0x9E,0x47,0x82,0xA4,0x57,0x24,],[0xC4,0x5E,0x82,0x06,0x92,0xE2,0xA4,0x05,0xE1,0xE3,0x47,0x57,0x6D,0xAC,0xAC,0xD7,0x44,0xD8,0x65,0x44,0x91,0x0A,0x17,0x04,0x85,0x0D,0x93,0xDF,0xEA,0x0B,0x8C,0xDC,]]'
  states: {}
- name: modulated_sync_word
  id: variable
  parameters:
    comment: 'TODO: unhardcode the 512'
    value: modulated_sync_word_pre[modulator_transient_delay:(512+modulator_transient_delay)]
  states: {}
- name: modulated_sync_word_pre
  id: variable_modulate_vector
  parameters:
    data: preamble1+preamble1
    mod: rxmod
    taps: '[1]'
  states: {}
- name: modulator_transient_delay
  id: variable
  parameters:
    value: '86'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: offset
  id: variable_qtgui_range
  parameters:
    label: Offset
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '200'
    value: '140'
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    label: Phase offset
    orient: Qt.Horizontal
    start: '-2*numpy.pi'
    step: numpy.pi / 2.0
    stop: 2*numpy.pi
    value: '0'
    widget: slider
  states: {}
- name: preamble1
  id: variable
  parameters:
    value: preambles[0]
  states: {}
- name: preamble2
  id: variable
  parameters:
    value: preambles[1]
  states: {}
- name: preambles
  id: variable
  parameters:
    value: text_preambles
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), eb, 5*sps*nfilts)
  states: {}
- name: rxmod
  id: variable
  parameters:
    value: digital.generic_mod(constel, False, sps, True, eb, False, False)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbols_per_byte
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tag_delay
  id: variable_qtgui_range
  parameters:
    label: Tag Delay
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
    widget: slider
  states: {}
- name: text_preambles
  id: variable
  parameters:
    value: '[list(bytearray(''PERSPECTA_LABS_WCTF_GRCON2019'',''UTF-8'')),list(bytearray(''first_to_solve_gets_the_prize'',''UTF-8''))]'
  states: {}
- name: bfutils_calc_array_weights_0
  id: bfutils_calc_array_weights
  parameters:
    bf_mode: bfutils.MMSE
    num_elements: '4'
    preamble: modulated_sync_word
  states: {}
- name: bfutils_pdu_pfb_clock_sync_0
  id: bfutils_pdu_pfb_clock_sync
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: 6.28/100.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
  states: {}
- name: bfutils_pdu_pfb_clock_sync_0_0
  id: bfutils_pdu_pfb_clock_sync
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: 6.28/100.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
  states: {}
- name: bfutils_polar_plot_0
  id: bfutils_polar_plot
  parameters:
    autoscale: 'True'
    gui_hint: 0,1,4,1
    log_scale: 'True'
    plot_depth: '70.0'
  states: {}
- name: bfutils_preamble_to_pdu_0
  id: bfutils_preamble_to_pdu
  parameters:
    corr_tag: corr_est
    data_length: 960+400
    num_elements: '1'
  states: {}
- name: bfutils_preamble_to_pdu_0_0
  id: bfutils_preamble_to_pdu
  parameters:
    corr_tag: '"corr_est"'
    data_length: len(modulated_sync_word)
    num_elements: '4'
  states: {}
- name: bfutils_preamble_to_pdu_0_0_0
  id: bfutils_preamble_to_pdu
  parameters:
    corr_tag: '"corr_est"'
    data_length: len(modulated_sync_word)+500
    num_elements: '1'
  states: {}
- name: bfutils_weights_to_matrix_a_0
  id: bfutils_weights_to_matrix_a
  parameters: {}
  states: {}
- name: bfutils_weights_to_plot_0
  id: bfutils_weights_to_plot
  parameters:
    log_response: 'True'
    num_elements: '4'
    sep_lambda: '0.5'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: len(modulated_sync_word)
    num_ports: '3'
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /share/git/grcon19/bfctfdata/grcon2019_ctf_5second_ota_marriott.dat
    repeat: 'True'
    type: complex
    vlen: '4'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: cmath.exp(1j*phase)
    type: complex
  states: {}
- name: blocks_multiply_matrix_xx_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: ((1+0j, 0+0j, 0+0j, 0+0j),)
    comment: |-
      Apply the weights to
       just the preamble 
      to beamform down 
      to a single stream
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '4'
    type: complex
  states: {}
- name: blocks_tagged_stream_to_pdu_1
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*4
    type: complex
    vlen: '4'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constel.bits_per_symbol()
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: M
    type: complex
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    comment: Outputs symbols 0,1,2,3
    constellation: constel
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: tag_delay
    sps: sps
    symbols: modulated_sync_word
    threshold: corr_calc
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_corr_est_cc_0_1
  id: digital_corr_est_cc
  parameters:
    mark_delay: tag_delay
    sps: sps
    symbols: modulated_sync_word
    threshold: corr_calc_2
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\nclass blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.basic_block.__init__(\n            self,\n            name='ASCII from PDU',   # will show up in GRC\n            in_sig=None,\n            out_sig=None\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.message_port_register_in(pmt.intern(\"pdu\"))\n        self.set_msg_handler(pmt.intern(\"pdu\"), self.handler)\n\n    \n    def handler(self, msg):\n        data = pmt.cdr(msg)\n        x = np.asarray(pmt.u8vector_elements(data),dtype=np.uint8)\n        print(x)\n        print(\"got {} bytes\".format(len(x)))\n\n        x[np.where(x>127)] = 32  # replace invalid ascii with space\n\n        s = x.astype(np.uint8).tostring().decode(\"UTF-8\")\n        print(s)\n        \n\n"
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import scipy
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '100'
    type: msg_complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: Correlation
    size: '102400'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Soft
    name: Corr Est
    size: '50000'
    srate: '1'
    type: float
    update_time: '0.05'
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Soft
    label2: Hard
    name: Symbols
    size: '1024'
    srate: '1'
    type: complex
    update_time: '0.05'
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Soft
    label2: Hard
    name: Recovered
    srate: '1'
    type: msg_complex
    update_time: '0.05'
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Soft
    name: Symbols
    size: '1024'
    srate: '1'
    type: float
    update_time: '0.05'
    ymax: '2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color3: black
    color4: cyan
    color5: magenta
    color6: yellow
    color7: dark red
    color8: dark green
    nconnections: '4'
    size: samp_rate*3*sps
    srate: '1'
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    comment: |-
      This is the output 
      of the ZMQ stream 
      from the TwinRx
    stream_id: ota
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: Decode
  states: {state: disabled}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: Decode
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: ota
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: Decode
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://192.168.10.101:1234
    timeout: '100'
    type: complex
    vlen: '4'
  states: {state: disabled}

connections:
- [bfutils_calc_array_weights_0, weights, bfutils_weights_to_matrix_a_0, weights]
- [bfutils_calc_array_weights_0, weights, bfutils_weights_to_plot_0, weights]
- [bfutils_pdu_pfb_clock_sync_0, pdu, blocks_pdu_to_tagged_stream_0_0, pdus]
- [bfutils_pdu_pfb_clock_sync_0, pdu, qtgui_const_sink_x_0, in]
- [bfutils_pdu_pfb_clock_sync_0_0, pdu, blocks_pdu_to_tagged_stream_0_0_0, pdus]
- [bfutils_preamble_to_pdu_0, pdus, bfutils_pdu_pfb_clock_sync_0, pdu]
- [bfutils_preamble_to_pdu_0, pdus, qtgui_time_sink_x_0_0_0_0_0, in]
- [bfutils_preamble_to_pdu_0_0, pdus, bfutils_calc_array_weights_0, pdus]
- [bfutils_preamble_to_pdu_0_0_0, pdus, bfutils_pdu_pfb_clock_sync_0_0, pdu]
- [bfutils_weights_to_matrix_a_0, A, blocks_multiply_matrix_xx_0, set_A]
- [bfutils_weights_to_plot_0, plot, bfutils_polar_plot_0, plot]
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_squared_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0, '0', blocks_streams_to_vector_0, '1']
- [blocks_delay_0, '0', qtgui_time_sink_x_1, '1']
- [blocks_delay_0, '1', blocks_streams_to_vector_0, '2']
- [blocks_delay_0, '1', qtgui_time_sink_x_1, '2']
- [blocks_delay_0, '2', blocks_streams_to_vector_0, '3']
- [blocks_delay_0, '2', qtgui_time_sink_x_1, '3']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_multiply_matrix_xx_0, '0', blocks_null_sink_0, '0']
- [blocks_multiply_matrix_xx_0, '0', digital_corr_est_cc_0_1, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', virtual_sink_1, '0']
- [blocks_pdu_to_tagged_stream_0_0_0, '0', virtual_sink_1_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_tagged_stream_to_pdu_1, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_streams_to_vector_0, '0', bfutils_preamble_to_pdu_0_0, '0']
- [blocks_tagged_stream_to_pdu_1, pdus, epy_block_1_0, pdu]
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0_0_0_0_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_vector_to_streams_0, '0', blocks_multiply_matrix_xx_0, '0']
- [blocks_vector_to_streams_0, '0', digital_corr_est_cc_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_delay_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_multiply_matrix_xx_0, '1']
- [blocks_vector_to_streams_0, '2', blocks_delay_0, '1']
- [blocks_vector_to_streams_0, '2', blocks_multiply_matrix_xx_0, '2']
- [blocks_vector_to_streams_0, '3', blocks_delay_0, '2']
- [blocks_vector_to_streams_0, '3', blocks_multiply_matrix_xx_0, '3']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_corr_est_cc_0, '0', bfutils_preamble_to_pdu_0_0_0, '0']
- [digital_corr_est_cc_0, '0', blocks_streams_to_vector_0, '0']
- [digital_corr_est_cc_0, '0', qtgui_time_sink_x_1, '0']
- [digital_corr_est_cc_0, '1', blocks_complex_to_mag_squared_0, '0']
- [digital_corr_est_cc_0_1, '0', bfutils_preamble_to_pdu_0, '0']
- [digital_corr_est_cc_0_1, '1', blocks_complex_to_mag_squared_1, '0']
- [virtual_source_0, '0', blocks_vector_to_streams_0, '0']
- [virtual_source_1, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_sub_source_0, '0', virtual_sink_0, '0']

metadata:
  file_format: 1
